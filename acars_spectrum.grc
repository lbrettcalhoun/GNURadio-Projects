<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048e3</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot - 130.5MHz</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>130.5e6</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>130.5e6</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>gain_mode0</key><value>1</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>0</value></param>
<param><key>freq1</key><value>136.75e6</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>dc_offset_mode1</key><value>0</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>gain_mode1</key><value>0</value></param>
<param><key>gain1</key><value>10</value></param>
<param><key>if_gain1</key><value>20</value></param>
<param><key>bb_gain1</key><value>20</value></param>
<param><key>ant1</key><value></value></param>
<param><key>bw1</key><value>0</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot - 136.75MHz</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>136.75e6</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
